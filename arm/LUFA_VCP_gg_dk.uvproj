# Keil uVision project LUFA_VCP_gg_dk.uvproj, settings and files
target LUFA_VCP_gg_dk (ARM-ADS)
  device: EFM32GG990F1024 Energy Micro
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0xFFFFF) CLOCK(48000000) CPUTYPE("Cortex-M3")
  output: LUFA_VCP_gg_dk
  AfterMake: fromelf.exe --bin --output obj\LUFA_VCP_gg_dk.bin obj\LUFA_VCP_gg_dk.axf
  c flags: Optim=1 oTime=1
  c define: EFM32GG990F1024
  c misc: --c99
  c include: ..\;..\..\..\CMSIS\Include;..\..\..\Device\SiliconLabs\EFM32GG\Include;..\..\..\emlib\inc;..\..\..\usb\inc;..\..\..\reptile\glib;..\..\..\kits\common\drivers;..\..\..\kits\common\bsp;..\..\..\kits\EFM32GG_DK3750\config;..\src\Demos\Device\LowLevel\EFM32Demos\VCP\Config;..\src\LUFA\Common;..\src\LUFA\Drivers\USB
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../../../Device/SiliconLabs/EFM32GG/Source/ARM/: startup_efm32gg.s
    ../../../Device/SiliconLabs/EFM32GG/Source/: system_efm32gg.c
  group Drivers
    ../../../kits/common/bsp/: bsp_dk_3201.c
  group emlib
    ../../../emlib/src/: em_assert.c em_cmu.c em_ebi.c em_emu.c em_gpio.c em_int.c em_system.c em_usart.c
  group Source
    ../src/Demos/Device/LowLevel/EFM32Demos/VCP/: VirtualSerial.c retarget.c Descriptors.c
    ../src/LUFA/Drivers/USB/Core/EFM32GG/: Device_EFM32GG.c Endpoint_EFM32GG.c EndpointStream_EFM32GG.c USBController_EFM32GG.c USBInterrupt_EFM32GG.c
    ../src/LUFA/Drivers/USB/Core/EFM32GG/Template/: Template_Endpoint_Control_R.c Template_Endpoint_Control_W.c Template_Endpoint_RW.c
    ../src/LUFA/Drivers/USB/Core/: DeviceStandardReq.c USBTask.c
