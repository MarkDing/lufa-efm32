<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\LUFA_VCP_gg_dk.ewp</path>
  </project>

  <batchBuild/>
</workspace>
