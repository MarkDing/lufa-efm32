# IAR project LUFA_VCP_gg_dk.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32GG990F1024 SiliconLaboratories EFM32GG990F1024
  ICCARM.CCDefines: EFM32GG990F1024
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Include; ..\..\..\Device\SiliconLabs\EFM32GG\Include; ..\..\..\emlib\inc; ..\..\..\usb\inc; ..\..\..\reptile\glib; ..\..\..\kits\common\drivers; ..\..\..\kits\common\bsp; ..\..\..\kits\EFM32GG_DK3750\config; ..\src\Demos\Device\LowLevel\EFM32Demos\VCP\Config; ..\src\LUFA\Common; ..\src\LUFA\Drivers\USB
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: LUFA_VCP_gg_dk.bin
  ILINK.IlinkOutputFile: LUFA_VCP_gg_dk.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32GG990F1024
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../Device/SiliconLabs/EFM32GG/Source/IAR/: startup_efm32gg.s
    ../../../Device/SiliconLabs/EFM32GG/Source/: system_efm32gg.c
  group Drivers
    ../../../kits/common/bsp/: bsp_dk_3201.c
  group emlib
    ../../../emlib/src/: em_assert.c em_cmu.c em_ebi.c em_emu.c em_gpio.c em_int.c em_system.c em_usart.c
  group Source
    ../src/Demos/Device/LowLevel/EFM32Demos/VCP/: VirtualSerial.c retarget.c Descriptors.c
    ../src/LUFA/Drivers/USB/Core/EFM32GG/: Device_EFM32GG.c Endpoint_EFM32GG.c EndpointStream_EFM32GG.c USBController_EFM32GG.c USBInterrupt_EFM32GG.c
    ../src/LUFA/Drivers/USB/Core/EFM32GG/Template/: Template_Endpoint_Control_R.c Template_Endpoint_Control_W.c Template_Endpoint_RW.c
    ../src/LUFA/Drivers/USB/Core/: DeviceStandardReq.c USBTask.c
